<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_0_1_1(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_1_0_5(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_2_0_5(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_3_1_1(IAR 7 50 2).ewp</path>
  </project>
  <batchBuild/>
</workspace>


