<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_0_3_2(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_1_2_2(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_2_2_2(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_3_3_2(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_4_1_2(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_5_1_2(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_10_1_2(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_11_1_2(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_13_0_2(IAR 7 50 2).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\v.14.00\device_2_v_14_15_1_2(IAR 7 50 2).ewp</path>
  </project>
  <batchBuild/>
</workspace>


