<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\v.14.00\device_2_v_14_0_1_1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\v.14.00\device_2_v_14_1_0_5.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\v.14.00\device_2_v_14_2_0_5.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\v.14.00\device_2_v_14_3_1_1.ewp</path>
    </project>
    <batchBuild />
</workspace>
