<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\v.9.02\device_2_v_9_2_0_0.ewp</path>
    </project>
    <batchBuild />
</workspace>
