# IAR project device_2_v_14_24_0_0.ewp, settings and files
configuration Flash-Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_TIME_USES_64; USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS; KEYBOARD_VER_2_1
  ICCARM.CCIncludePath2: ..\..\working files\inc; ..\..\working files\inc\a.24.c.d; ..\..\working files\usb; ..\..\working files\src\modbusroutine\inc; ..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc; ..\..\Middlewares\FatFs\inc; ..\..\SystemView\Config; ..\..\SystemView\OS; ..\..\SystemView\SEGGER
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: device_2_v_14_24_0_0.bin
  ILINK.IlinkOutputFile: device_2_v_14_24_0_0.out
  ILINK.IlinkIcfFile: ..\without iec61850\stm32f2xx_flash.icf
  ILINK.IlinkExtraOptions: --timezone_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS/inc
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Include/: stm32f2xx.h system_stm32f2xx.h
  group CMSIS/src
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group FatFs/inc
    ../../Middlewares/FatFs/inc/: diskio.h fatfs.h ff.h ff_gen_drv.h ffconf.h ffconf_template.h integer.h user_diskio.h
  group FatFs/src
    ../../Middlewares/FatFs/src/: diskio.c fatfs.c ff.c ff_gen_drv.c user_diskio.c
  group lib/runtime
    ../../working files/lib/runtime/: stack_protection.c
  group lib/time
    ../../working files/time/: clock.c getzone.c time.c time64.c
  group Linker
    ../: stm32f2xx_flash_extsram.icf stm32f2xx_sram.icf
  group Linker/without iec61850
    ../without iec61850/: StackDepth.suc stm32f2xx_flash.icf
  group Startup
    ../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
  group STM_Periph_Driver/inc
    ../../Libraries/STM32F2xx_StdPeriph_Driver/inc/: misc.h stm32f2xx_dbgmcu.h stm32f2xx_dma.h stm32f2xx_exti.h stm32f2xx_gpio.h stm32f2xx_i2c.h stm32f2xx_rcc.h stm32f2xx_spi.h stm32f2xx_syscfg.h stm32f2xx_tim.h stm32f2xx_usart.h
  group STM_Periph_Driver/src
    ../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group SystemView/Config
    ../../SystemView/Config/: Global.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_Config_NoOS.c
  group SystemView/SEGGER
    ../../SystemView/SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group USB Device/Class/CDC/inc
    ../../Libraries/STM32_USB_Device_Library/Class/cdc/inc/: usbd_cdc_core.h
  group USB Device/Class/CDC/src
    ../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB Device/Library/inc
    ../../Libraries/STM32_USB_Device_Library/Core/inc/: usbd_core.h usbd_def.h usbd_ioreq.h usbd_req.h usbd_usr.h
  group USB Device/Library/src
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB Driver/inc
    ../../Libraries/STM32_USB_OTG_Driver/inc/: usb_bsp.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
  group USB Driver/src
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group user/inc/EEPROM
    ../../working files/inc/: const_eeprom.h
  group user/inc/FSMC
    ../../working files/inc/: const_fsmc.h
  group user/inc/general
    ../../working files/inc/: const_septoints_interval.h constants.h functions_external.h functions_global.h header.h libraries.h macroses.h type_definition.h variables_external.h variables_global.h
  group user/inc/general/a.24.c.d
    ../../working files/inc/a.24.c.d/: const_global.h
  group user/inc/I2C
    ../../working files/inc/: const_i2c.h
  group user/inc/interfaces
    ../../working files/inc/: const_interfaces.h
  group user/inc/Log
    ../../working files/src/log/: cmd_log.h
  group user/inc/menu
    ../../working files/inc/: const_lcd_and_keyboard.h const_menu_achr_chapv.h const_menu_apv.h const_menu_buttons.h const_menu_chose_communication_parameters.h const_menu_chose_data_time_settings.h const_menu_chose_extra_settings.h const_menu_chose_grupa_ustavok.h const_menu_chose_settings.h const_menu_chose_settings_protection.h const_menu_chose_settings_registrators.h const_menu_chose_settings_switcher.h const_menu_chose_settings_uvv.h const_menu_configuration.h const_menu_d_and.h const_menu_d_not.h const_menu_d_or.h const_menu_d_xor.h const_menu_df.h const_menu_dt.h const_menu_extended_logic.h const_menu_general_pickups_el.h const_menu_info.h const_menu_leds.h const_menu_level_password.h const_menu_main.h const_menu_measurement.h const_menu_mtz.h const_menu_mtz04.h const_menu_point_time_settings.h const_menu_registrators.h const_menu_resurs.h const_menu_setting_language.h const_menu_state_inputs_outputs.h const_menu_switch.h const_menu_time.h const_menu_transfer_functions.h const_menu_transformator.h const_menu_tznp.h const_menu_Umax.h const_menu_Umin.h const_menu_UP.h const_menu_urov.h const_menu_vidkluchennja.h const_menu_VMP.h const_menu_zdz.h const_menu_zop.h const_menu_zz.h
  group user/inc/menu/a.24.c.d
    ../../working files/inc/a.24.c.d/: const_menu_outputs.h
  group user/inc/menu/without iec61850
    ../../working files/inc/without iec61850/: const_menu_diagnostyka.h const_menu_inputs.h
  group user/inc/microcontriller
    ../../working files/inc/: hw_config.h platform_config.h stm32f2xx_conf.h stm32f2xx_it.h
  group user/inc/protection
    ../../working files/inc/: const_global_timers.h const_koef_povernennja.h const_measurement.h const_watchdog.h
  group user/inc/Serial Dataflash
    ../../working files/inc/: const_driver_serial_dataflash.h
  group user/src/EEPROM
    ../../working files/src/: eeprom.c
  group user/src/FSMC
    ../../working files/src/: fsmc_sram.c
  group user/src/general
    ../../working files/src/: main.c procedures.c start_settings.c
  group user/src/I2C
    ../../working files/src/: i2c.c
  group user/src/interfaces
    ../../working files/src/: interfaces.c modbus.c
  group user/src/interfaces/component
    ../../working files/src/modbusroutine/component/: ACMDSmallComponent.c AISmallComponent.c DOUTSmallComponent.c DVSmallComponent.c GCMDSmallComponent.c IUSmallComponent.c PERIFComponent2021.c PKVBigComponent.c PREGBigComponent.c PROTComponent2021.c QAISmallComponent.c REG1BigComponent.c REG2BigComponent.c RPRSmallComponent.c SDISmallComponent.c UVVComponent2021.c YustBigComponent.c
  group user/src/interfaces/component/filePERIF2021
    ../../working files/src/modbusroutine/component/filePERIF2021/: filePERIF_ANLCONF1Register20.c filePERIF_ANLDATA1Register20.c filePERIF_ANLDATA2Register20.c filePERIF_ANLDATA3Register20.c filePERIF_BLOCKDSRegister2021.c filePERIF_CTRLVVRegister2021.c filePERIF_DRCONF1Register20.c filePERIF_DRDATA1Register20.c filePERIF_DRDATA2Register20.c filePERIF_DSREGRegister20.c filePERIF_ELANDRegister2021.c filePERIF_ELDTRRegister2021.c filePERIF_ELMFTRegister2021.c filePERIF_ELNOTRegister2021.c filePERIF_ELORRegister2021.c filePERIF_ELPFRegister2021.c filePERIF_ELXORRegister2021.c filePERIF_OMPRegister2021.c filePERIF_PKV1Register2021.c filePERIF_PKV2Register2021.c filePERIF_PKV3Register2021.c filePERIF_PKV4Register2021.c filePERIF_PKV5Register2021.c filePERIF_PKV6Register2021.c filePERIF_PLINERegister2021.c filePERIF_RAIRegister20.c filePERIF_REGANLRegister2021.c filePERIF_REGDISRegister2021.c filePERIF_TRANSRegister2021.c
  group user/src/interfaces/component/filePROT2021
    ../../working files/src/modbusroutine/component/filePROT2021/: filePROT_AJRRegister2021.c filePROT_APVRegister2021.c filePROT_COMMRegister2021.c filePROT_MTZ04Register2021.c filePROT_MTZRegister2021.c filePROT_NZZRegister2021.c filePROT_TZNPRegister2021.c filePROT_UPRegister2021.c filePROT_UROVRegister2021.c filePROT_ZDZRegister2021.c filePROT_ZNMAXRegister2021.c filePROT_ZNMINRegister2021.c filePROT_ZOPRegister2021.c
  group user/src/interfaces/component/fileUVV2021
    ../../working files/src/modbusroutine/component/fileUVV2021/: fileUVV_DOUTRegister2021.c fileUVV_DVRegister2021.c fileUVV_KEYRegister2021.c fileUVV_RPRRegister2021.c fileUVV_SDIRegister2021.c
  group user/src/interfaces/inc
    ../../working files/src/modbusroutine/inc/: componentdef.h componentenum.h prototyps.h variables_external_m.h variables_global_m.h
  group user/src/interfaces/modbusroutine
    ../../working files/src/modbusroutine/: procedures_guest.c procedures_m.c procedures_rdsguest.c start_settings_m.c supervisor.c uprFunc000for2021.c ustFunc000for2021.c
  group user/src/interrupts
    ../../working files/src/: interrupts.c
  group user/src/Log
    ../../working files/src/log/: log.c
  group user/src/menu
    ../../working files/src/: driver_lcd.c menu.c menu_achr_chapv.c menu_apv.c menu_chose_communication_parameters.c menu_chose_extra_settings .c menu_chose_grupa_ustavok.c menu_chose_settings.c menu_chose_settings_protection.c menu_chose_settings_registrators.c menu_chose_settings_uvv.c menu_configuration.c menu_data_time_settings.c menu_df.c menu_diagnostyka.c menu_dt.c menu_energy.c menu_extended_logic.c menu_general_pickups_el.c menu_info.c menu_inputs_outputs_leds_reg_df_buttons.c menu_level_password.c menu_main.c menu_mtz.c menu_mtz04.c menu_point_time_settings.c menu_registrators.c menu_resurs.c menu_setting_language.c menu_state_inputs_outputs.c menu_switch.c menu_tf.c menu_time.c menu_transformator.c menu_tznp.c menu_Umax.c menu_Umin.c menu_UP.c menu_urov.c menu_vidkluchennja.c menu_view_measurement.c menu_VMP.c menu_zdz.c menu_zop.c menu_zz.c
  group user/src/microcontroller
    ../../working files/src/: hw_config.c stm32f2xx_it.c
  group user/src/protection
    ../../working files/src/: ar_routines.c measurement.c protections.c
  group user/src/Serial Dataflash
    ../../working files/src/: driver_serial_dataflash.c
  group user/usb/inc
    ../../working files/usb/: usb_conf.h usbd_cdc_vcp.h usbd_conf.h usbd_desc.h
  group user/usb/src
    ../../working files/usb/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
