<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\v.9.02\device_2_v_9_2_0_0(IAR 7 50 2).ewp</path>
  </project>
  <batchBuild/>
</workspace>


